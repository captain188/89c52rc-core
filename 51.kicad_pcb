# Repository captain188/89c52rc-core

## KiCad design 51.kicad_pcb

Parts:
C1, C2, C3, C6, C7: 104; C_0805_2012Metric
C8, C9: 22pf; C_0805_2012Metric
C10: 10uf; C_0805_2012Metric
D1: 1N4148; D_1206_3216Metric
D2: 红色; LED_0805_2012Metric
D3: 蓝色; LED_0805_2012Metric
D4, D5, D6: 白色; LED_0805_2012Metric
DR1: SMBJ5.0A-E3/52; D_SMB
J1, J2, J8, J9: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J4, J5, J6, J7: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
R1, R5, R9, R10: 10K; R_0805_2012Metric
R2: 22R; R_0805_2012Metric
R3, R4, R6, R7, R8: 2K; R_0805_2012Metric
S1: SS-12F23; SW_SPDT_PCM12
SW1, SW2, SW3: SW_Push; SW_SPST_CK_RS282G05A3
TH1: SMD1812P110TF/33; C_1812_4532Metric
U1: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U2: STC89C52RC; LQFP-44_10x10mm_P0.8mm
USBC1: USB_C_Receptacle; USB_C_Receptacle_XKB_U262-16XN-4BVC11
Y1: 11.0592Mhz; Crystal_HC18-U_Vertical

Connections:
+5V: C7.1, C10.1, J1.1, J2.1, J2.3, J8.1, J8.3, J9.1, J9.3, R1.1, R3.2, R4.2, R5.1, R6.2, R7.2, R8.2, R9.1, S1.3 (C), SW3.2, U2.38 (VCC)
/DM: U1.6 (UD-), USBC1.A7 (D-), USBC1.B7 (D-)
/DP: U1.5 (UD+), USBC1.A6 (D+), USBC1.B6 (D+)
/KEY1: C3.2, J6.14, R1.2, SW1.1, U2.19 (P2.1)
/KEY2: C6.2, J6.16, R5.2, SW2.1, U2.18 (P2.0)
/LED1: D5.1 (K), J7.15, U2.13 (P3.7/~RD)
/LED2: D6.1 (K), J7.13, U2.12 (P3.6/~WR)
/P0.0: J4.2, U2.37 (P0.0)
/P0.1: J4.4, U2.36 (P0.1)
/P0.2: J4.6, U2.35 (P0.2)
/P0.3: J4.8, U2.34 (P0.3)
/P0.4: J4.10, U2.33 (P0.4)
/P0.5: J4.12, U2.32 (P0.5)
/P0.6: J4.14, U2.31 (P0.6)
/P0.7: J4.16, U2.30 (P0.7)
/P1.0: J5.1, U2.40 (T2/P1.0)
/P1.1: J5.3, U2.41 (T2EX/P1.1)
/P1.2: J5.5, U2.42 (P1.2)
/P1.3: J5.7, U2.43 (P1.3)
/P1.4: J5.9, U2.44 (P1.4)
/P1.5: J5.11, U2.1 (P1.5)
/P1.6: J5.13, U2.2 (P1.6)
/P1.7: J5.15, U2.3 (P1.7)
/P2.2: J6.12, U2.20 (P2.2)
/P2.3: J6.10, U2.21 (P2.3)
/P2.4: J6.8, U2.22 (P2.4)
/P2.5: J6.6, U2.23 (P2.5)
/P2.6: J6.4, U2.24 (P2.6)
/P2.7: J6.2, U2.25 (P2.7)
/P3.0: D1.2 (A), D3.1 (K), J1.4, J7.1, U2.5 (P3.0/RXD)
/P3.1: D2.1 (K), J1.3, J7.3, R2.1, U2.7 (P3.1/TXD)
/P3.2: J7.5, U2.8 (P3.2/~INT0)
/P3.3: J7.7, U2.9 (P3.3/~INT1)
/P3.4: J7.9, U2.10 (P3.4/T0)
/P3.5: J7.11, U2.11 (P3.5/T1)
/P4.0: J3.5, U2.17 (P4.0)
/P4.1: J3.11, U2.28 (P4.1)
/P4.2: J3.3, U2.39 (~INT3/P4.2)
/P4.3: J3.1, U2.6 (P4.3/~INT2)
/P4.4: J3.7, U2.26 (~PSEN/P4.4)
/P4.5: J3.9, U2.27 (ALE/P4.5)
/P4.6: J3.13, R9.2, U2.29 (~EA/P4.6)
/RST: C10.2, R10.1, SW3.1, U2.4 (RST)
/X1: C8.1, U2.15 (XTAL1), Y1.1
/X2: C9.1, U2.14 (XTAL2), Y1.2
GND: C1.2, C2.1, C3.1, C6.1, C7.2, C8.2, C9.2, D4.1 (K), DR1.2 (A2), J1.2, J2.2, J2.4, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J4.1, J4.3, J4.5, J4.7, J4.9, J4.11, J4.13, J4.15, J5.2, J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, J6.13, J6.15, J7.2, J7.4, J7.6, J7.8, J7.10, J7.12, J7.14, J7.16, J8.2, J8.4, J9.2, J9.4, R10.2, SW1.2, SW2.2, U1.1 (GND), U2.16 (GND), USBC1.A1 (GND), USBC1.A12 (GND), USBC1.B1 (GND), USBC1.B12 (GND)
unnamed: C2.2, U1.4 (V3)
unnamed: D1.1 (K), U1.2 (TXD)
unnamed: D2.2 (A), R3.1
unnamed: D3.2 (A), R4.1
unnamed: D4.2 (A), R6.1
unnamed: D5.2 (A), R7.1
unnamed: D6.2 (A), R8.1
unnamed: R2.2, U1.3 (RXD)
VBUS: TH1.2, USBC1.A4 (VBUS), USBC1.A9 (VBUS), USBC1.B4 (VBUS), USBC1.B9 (VBUS)
VCC: C1.1, DR1.1 (A1), S1.2 (B), TH1.1, U1.16 (VCC)

Notes on the sheet:
太阳1号开发板

Board: 2 copper layers, 80.0 x 55.0 mm, 43 parts (0 on the bottom side), 56 nets.

## Commit log

2022-04-17 原理图0.1
2022-06-02 V0.1 COMPLETE
2022-06-02 V0.1.1 加引脚丝印
2022-07-19 Added 连线图
